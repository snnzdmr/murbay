# Keil uVision project scale_v2.uvprojx, settings and files
target scale_v2 (6180000::V6.18::ARMCLANG)
  device: M251SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: scale_v2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __HXT=24000000ul __LXT=0ul
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c i2c.c retarget.c spi.c sys.c timer.c timer_pwm.c uart.c wdt.c tk.c
    ../../../../Library/TKLib/: TKLib_Calibration.lib TKLib_FreeRun.lib
  group User
    ../: main.c clk_conf.c periph_conf.c pin_conf.c int_handler.c
  group src
    ../src/: app.c costumLcd.c keypad.c menu.c millis.c SparkFun_NAU7802.c test.c eeproom.c
  group Inc
    ../Inc/: app.h costumLcd.h font.h keypad.h menu.h millis.h SparkFun_NAU7802.h test.h eeproom.h
